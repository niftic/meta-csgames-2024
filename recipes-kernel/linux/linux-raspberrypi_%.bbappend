FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
                  file://enable-tun.cfg"
